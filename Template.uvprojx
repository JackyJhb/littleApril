# Keil uVision project Template.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: .\User;.\Libraries\CMSIS;.\Libraries\STM32F4xx_StdPeriph_Driver\inc;.\APP\USART;.\APP\CAN;.\APP\PhotoElectricIsolation;.\APP\led;.\Public;.\APP\beep;.\APP\key;.\APP\exti;.\APP\time;.\APP\Keyboard;.\APP\pwm;.\UCOSIII\uC-BSP;.\UCOSIII\uC-CONFIG;.\UCOSIII\uC-CPU;.\UCOSIII\uC-LIB;.\UCOSIII\uCOS-III;.\UCOSIII\uC-CPU\ARM-Cortex-M4\RealView;.\UCOSIII\uC-LIB\Ports\ARM-Cortex-M4\RealView;.\UCOSIII\uCOS-III\Source;.\UCOSIII\uCOS-III\Ports\ARM-Cortex-M4\Generic\RealView;.\APP\Protocol;.\APP\PID;.\APP\stm32_flash;.\APP\24C02;.\APP\RTC;.\APP\wifi;.\APP\LCD;.\APP\led;.\APP\beep;.\APP\adc;.\APP\ds18b20;.\APP\MQTT;.\APP\CircleBuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ./User/: main.c stm32f4xx_it.c led_task.c usart_task.c envctrl_task.c main_task.c wifi_task.c alarm_task.c rtc_task.c ts_task.c ventilation_task.c watcher_task.c task_monitor.c sidewindowctrl_task.c default_config.c waterpumpctrl_task.c
  group Startup
    ./Libraries/CMSIS/: startup_stm32f40_41xxx.s
  group StdPeriph_Driver
    ./Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_syscfg.c misc.c stm32f4xx_exti.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_can.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_pwr.c stm32f4xx_rtc.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_iwdg.c stm32f4xx_dma.c
  group CMSIS
    ./Libraries/CMSIS/: system_stm32f4xx.c
  group Public
    ./Public/: system.c usart.c SysTick.c
  group APP
    ./APP/led/: led.c
    ./APP/beep/: beep.c
    ./APP/exti/: exti.c
    ./APP/CAN/: bsp_can.c
    ./APP/Keyboard/: bsp_button.c
    ./APP/PhotoElectricIsolation/: bsp_gpio.c
    ./APP/PID/: pid.c
    ./APP/stm32_flash/: stm32_flash.c
    ./APP/24C02/: 24c02.c
    ./User/: sccf.c
    ./APP/RTC/: rtc.c
    ./APP/adc/: adc.c
    ./APP/ds18b20/: ds18b20.c
    ./APP/wifi/: wifi.c
    ./APP/MQTT/: mqtt.c
    ./APP/CircleBuffer/: circleBuffer.c
  group UCOSIII_CPU
    ./UCOSIII/uC-CPU/: cpu_core.c
    ./UCOSIII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_c.c cpu_a.asm
  group UCOSIII_BSP
    ./UCOSIII/uC-BSP/: bsp.c
  group UCOSIII_LIB
    ./UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ./UCOSIII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSIII_CORE
    ./UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII_PORT
    ./UCOSIII/uCOS-III/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSIII_CONFIG
    ./UCOSIII/uC-CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
